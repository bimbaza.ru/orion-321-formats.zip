Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:31+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-33557-2
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс игровой детский, ZSK-33557-2 Игровой комплекс «Спиральный Путь»
In: Площадка
Description: Комплекс игровой детский. Игровой комплекс «Спиральный Путь»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР)); Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-33557-2; ModelReference: Игровой комплекс «Спиральный Путь»; ProductionYear: 2026; ArticleNumber: ZSK-33557-2
ORION_Изделие - Артикул: ZSK-33557-2; Артикул прежний: SD-33557-2; Наименование: Игровой комплекс «Спиральный Путь»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 5.2 x 4.9 м; Зона безопасности: 9.00 x 8.70 м; Высота свободного падения: 2.1 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 3 800 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/play-complexes/321; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Игровой комплекс «Спиральный Путь»; ADSK_Марка: ZSK-33557-2; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/play-complexes/321
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 9.00 x 8.70 м; ZSK_Высота_свободного_падения: 2.1 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-33557-2
Qto_ORION - Длина: 5200 mm; Ширина: 4900 mm; Высота: 0 mm
